<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rfnoc_rxtx</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>master_clock_rate</value></param>
<param><key>value</key><value>200e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>value</key><value>2.46e9</value></param>
<param><key>label</key><value>TX Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>50e6</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>stop</key><value>6e9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>label</key><value>TX Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>30</value></param>
</block>
<block>
<key>variable_uhd_device3</key>
<param><key>id</key><value>variable_uhd_device3_0</value></param>
<param><key>dev_addr</key><value>type=x300</value></param>
<param><key>dev_args</key><value>"addr=192.168.50.2"</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>blocks_copy_0</value></param>
<param><key>enabled</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr
import time

class iq_file_source(gr.sync_block):
    def __init__(self, file_path="/home/imdea/Documents/RFNOC_ANTHONY/MATLAB/IQ_SAMPLES_MCS_1_1pk.txt"):
        gr.sync_block.__init__(self,
            name="iq_file_source",
            in_sig=None,
            out_sig=[np.complex64])

        self.file_path = file_path  # Guarda la ruta del archivo
        self.samples = self.load_samples()  # Carga las muestras
        self.idx = 0

    def load_samples(self):
        # Cargar las muestras I/Q desde el archivo binario
        with open(self.file_path, 'rb') as f:
            samples = np.fromfile(f, dtype=np.complex64)
        return samples

    def work(self, input_items, output_items):
        out = output_items[0]
        num_output_samples = len(out)
        num_remaining_samples = len(self.samples) - self.idx  # Muestras restantes
        num_samples_to_send = min(num_output_samples, num_remaining_samples)

        if num_samples_to_send &gt; 0:
            # Enviar las muestras I/Q
            out[:num_samples_to_send] = self.samples[self.idx:self.idx + num_samples_to_send]
            self.idx += num_samples_to_send
        else:
            time.sleep(5e-3)
            self.idx = 0
            return 0

        return num_samples_to_send

# Bloque de GNU Radio
class iq_file_source_block(gr.hier_block2):
    def __init__(self, file_path=""):
        gr.hier_block2.__init__(self,
            "iq_file_source_block",
            gr.io_signature(0, 0, 0),  # Sin entradas
            gr.io_signature(1, 1, gr.sizeof_gr_complex))  # Una salida compleja

        self.iq_source = iq_file_source(file_path)
        self.connect(self.iq_source, self)</value></param>
<param><key>file_path</key><value>'/home/imdea/Documents/RFNOC_ANTHONY/MATLAB/IQ_SAMPLES_MCS_1_1pk.txt'</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import log</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from math import ceil</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_dma_fifo</key>
<param><key>id</key><value>uhd_rfnoc_streamer_dma_fifo_0</value></param>
<param><key>base_addr_0</key><value>0</value></param>
<param><key>base_addr_1</key><value>33554432</value></param>
<param><key>depth_0</key><value>int(2**(ceil(log(samp_rate/master_clock_rate*(2**25),2))))</value></param>
<param><key>depth_1</key><value>33554432</value></param>
<param><key>otw</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_axi_dma_fifo</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>num_chans</key><value>1</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_duc</key>
<param><key>id</key><value>uhd_rfnoc_streamer_duc_0</value></param>
<param><key>block_index</key><value>-1</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>fpga_module_name</key><value>noc_block_duc</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>freq</key><value>0.0</value></param>
<param><key>fullscale</key><value>1.0</value></param>
<param><key>input_rate</key><value>samp_rate</value></param>
<param><key>output_rate</key><value>master_clock_rate</value></param>
</block>
<block>
<key>uhd_rfnoc_streamer_radio</key>
<param><key>id</key><value>uhd_rfnoc_streamer_radio_0</value></param>
<param><key>rx_bandwidth0</key><value>56e6</value></param>
<param><key>ant0</key><value>AB</value></param>
<param><key>freq0</key><value>0</value></param>
<param><key>dcenable0</key><value>True</value></param>
<param><key>gain0</key><value>5</value></param>
<param><key>lo_export0</key><value>False</value></param>
<param><key>lo_source0</key><value>"internal"</value></param>
<param><key>rx_bandwidth1</key><value>56e6</value></param>
<param><key>ant1</key><value></value></param>
<param><key>freq1</key><value>1.982e9</value></param>
<param><key>dcenable1</key><value>True</value></param>
<param><key>gain1</key><value>20</value></param>
<param><key>lo_export1</key><value>False</value></param>
<param><key>lo_source1</key><value>"internal"</value></param>
<param><key>otw_format</key><value>sc16</value></param>
<param><key>device_index</key><value>-1</value></param>
<param><key>grvlen</key><value>1</value></param>
<param><key>cpu_format</key><value>fc32</value></param>
<param><key>source</key><value>"internal"</value></param>
<param><key>direction</key><value>tx</value></param>
<param><key>num_channels</key><value>1</value></param>
<param><key>radio_index</key><value>0</value></param>
<param><key>rate</key><value>master_clock_rate</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>stream_args</key><value></value></param>
</block>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_dma_fifo_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_1</source_block_id><sink_block_id>blocks_copy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_dma_fifo_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_duc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_rfnoc_streamer_duc_0</source_block_id><sink_block_id>uhd_rfnoc_streamer_radio_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
